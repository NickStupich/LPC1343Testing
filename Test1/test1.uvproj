# Keil uVision project test1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test1
  c flags: Optim=4 oTime=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_LPC13xx.s main.c pll.h fft1.h fft2.h fft3.h Ek_FFT128Real_32b.s Ek_Magnitude.s
