# Keil uVision project mmm2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1343 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: mmm2 +hex
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: Ek_FFT128Real_32b.s Ek_Magnitude.s startup_LPC13xx.s coreFunctions.c fft.c main.c systemClock.c timers.c uart.c coreFunctions.h fft.h lpc1343Constants.h settings.h systemClock.h timers.h uart.h ads_spi.c ads_spi.h events.c downSampling.c ads1298Constants.h settings.c
